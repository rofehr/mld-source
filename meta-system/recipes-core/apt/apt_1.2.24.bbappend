SUMMARY = "MLD patch for apt package"
HOMEPAGE = "http://www.minidvblinux.de"

#DEPENDS = "curl db"
#RDEPENDS_${PN} = " dpkg debianutils"
