
INITRAMFS_MAXSIZE ??= "262144"

PACKAGE_INSTALL += " \
    kernel-modules\
    base \
    findutils \
    init-mld \
    initramfs \
    install \
    locales \
    network \
    ssh-mld \
    udev-mld \
    urldecode \
    webserver \
    gettext \
    gettext-runtime \
    init-ifupdown \
    network \
    "    
